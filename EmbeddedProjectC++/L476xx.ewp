# IAR project L476xx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: EWARM; __cplusplus; STM32L476xx
  ICCARM.CCIncludePath2: CMSIS; src; myLib/common; myLib/devices; myLib/interfaces
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: L432xx.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: hal.cpp hal.h main.cpp motionControl.cpp motionControl.h sysl476xx.cpp sysl476xx.h
    myLib/common/: spbtle.cpp
    myLib/interfaces/: x_handler.cpp
  group CMSIS
    CMSIS/: startup_stm32l476xx.s stm32l476xx.h stm32l4xx.h system_stm32l4xx.c system_stm32l4xx.h
  group myLib/common
    myLib/common/: buffer.cpp buffer.h comhandler.cpp comhandler.h gpio.cpp gpio.h gpioex.cpp gpioex.h httpparser.cpp spidevice.cpp spidevice.h spiport.cpp spiport.h stopwatch.cpp stopwatch.h timehandler.cpp uart.cpp uart.h unixtime.cpp
  group myLib/devices
    myLib/devices/: spw04sx.cpp stm32rtc.cpp
  group myLib/interfaces
    myLib/interfaces/: comport.cpp comport.h x_gpio.cpp x_gpio.h x_rtc.cpp x_spiport.cpp x_spiport.h x_system.cpp x_system.h
