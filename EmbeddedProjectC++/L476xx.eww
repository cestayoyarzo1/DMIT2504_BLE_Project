<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\L476xx.ewp</path>
        <scc>
            <provider>Subversion</provider>
            <projname>notused</projname>
            <auxprojpath>notused</auxprojpath>
        </scc>
    </project>
    <batchBuild />
</workspace>
